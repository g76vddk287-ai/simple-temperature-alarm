# Keil uVision project facemask_id_temp_threshold_2key_final.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: facemask_id_temp_threshold_2key_final +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\lib\inc;.\system;.\pack\Keil\STM32F1xx_DFP\2.4.0\Device\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: facemask_id_temp_threshold_2key_final.c
    ./startup/: startup_stm32f10x_md.s
    ./system/: system_stm32f10x.c
    ./lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
